# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__RTX
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\RL-ARM\Config;..\..\RL-ARM\Driver;..\..\RL-ARM\RL-RTX\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h SysInfoTest.c FreeRTOSConfig.h
    ../../RL-ARM/Config/: Net_lib.c Net_Config.c Net_Debug.c
  group APP
    ../../User/libapp/: app_tcpnet_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c bsp_tim_pwm.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group RL-TCPnet/Lib
    ../../RL-ARM/RL-TCPnet/: TCPD_CM3.lib
  group RL-TCPnet/Driver
    ../../RL-ARM/Driver/: ETH_STM32F4xx.c ETH_STM32F4xx.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
